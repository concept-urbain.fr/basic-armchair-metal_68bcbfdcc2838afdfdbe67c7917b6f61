Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Basic Fauteuil métal.IFC
Time: 2020-05-06T09:20:46
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: BASI-FAU-CAI-005_Default
In: Default Storey
Material: 0

# IfcBeam: BASI-FAU-CAI-007_Default (2)
In: Default Storey
Material: 0

# IfcBeam: BASI-MUL-005_Default
In: Default Storey
Material: 0

# IfcBeam: FHC M8x25 A2_Default
In: Default Storey
Material: 0

# IfcBeam: ROND-M8-A2_Default (2)
In: Default Storey
Material: 0

# IfcBeam: TBHC-M8x30-A2_Default (5)
In: Default Storey
Material: 0

# IfcBuildingElementProxy: BASI-FAU-CAI-004_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-FAU-CAI-005_Default (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-FAU-CAI-006_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-FAU-CAI-007_Default (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-MUL-001_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-MUL-002_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-MUL-005_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-MUL-006_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-MUL-007_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-MUL-008_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: BASI-MUL-009_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: FHC M8x25 A2_Default (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: INS-TAFF-M8-1.5-5-A2_Default (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ROND-M8-A2_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TBHC-M8x30-A2_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0
